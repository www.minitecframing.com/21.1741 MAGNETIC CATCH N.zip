# Autodesk Inventor assembly: 21.1741 MAGNETIC CATCH N
## iProperties
Created: 2007-03
Part Number: 21.1741 MAGNETIC CATCH N
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
